# Keil uVision project Timer0_m1.uvproj, settings and files
target C1_SK_beepswitch_trans_param (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: C1_SK_beepswitch_trans_param +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\Library\Device\Include;..\Library\StdDriver\inc;..\user;..\driver;..\bsp;..\Include;..\common
  group startcode
    ../Startup/: STARTUP.A51
  group driver
    ../driver/: 7_segment.c aip1628.c indecate.c led_disp.c keypad.c keypad_fun.c beep.c
  group user
    ../user/: main.c queue.c uart_frame.c treadmills.c param.c
  group bsp
    ../bsp/: isr.c PWM_simple.c Timer01_M1.c uart.c ee_param.c IAP_EEPROM.c
  group common
    ../Common/: Delay.c Common.c
